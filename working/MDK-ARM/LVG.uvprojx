# Keil uVision project LVG.uvprojx, settings and files
target LVG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: LVG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;../Src;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../Newfolder(2);../../Newfolder;../../../Newfolder(2);../../../Newfolder;../../../New folder;../../../New folder (2);../middlewares/st/touchgfx/framework/include;../src/generated/fonts/include;../src/generated/gui_generated/include;../src/generated/images/include;../src/generated/texts/include;../src/generated/videos/include;../src/gui/include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../../../New folder (2)/: xpt2046.c xpt2046.h ILI9341.c ILI9341.h
    ../../../New folder/: TouchGFX_DataTransfer.c TouchGFX_DataTransfer.h
    ../Src/: main.c TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXHAL.cpp STM32TouchController.cpp STM32DMA.cpp OSWrappers.cpp TouchGFXGPIO.cpp app_touchgfx.c stm32f4xx_it.c nema_hal_threadx.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group gui
    ../src/gui/src/common/: frontendapplication.cpp
    ../src/gui/src/model/: model.cpp
    ../src/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../src/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
    ../src/gui/src/screen3_screen/: screen3presenter.cpp screen3view.cpp
    ../src/gui/src/screen4_screen/: screen4presenter.cpp screen4view.cpp
    ../src/gui/src/screen5_screen/: screen5presenter.cpp screen5view.cpp
  group generated
    ../src/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_25_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_25_4bpp.cpp kerning_verdana_40_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_25_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp
    ../src/generated/images/src/: bitmapdatabase.cpp image_4354727.cpp image_love.cpp
    ../src/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../src/generated/images/src/__designer/: image_blue_buttons_round_edge_small.cpp image_blue_buttons_round_edge_small_pressed.cpp image_blue_togglebars_toggle_round_large_button_off.cpp image_blue_togglebars_toggle_round_large_button_on.cpp
    ../src/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../src/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../src/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
    ../src/generated/gui_generated/src/screen3_screen/: screen3viewbase.cpp
    ../src/generated/gui_generated/src/screen4_screen/: screen4viewbase.cpp
    ../src/generated/gui_generated/src/screen5_screen/: screen5viewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
software components: CMSIS:CORE 4.3.0
